# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\STM32F10x_FWLib\src;..\OBJ;..\HARDWARE\GPRS;..\SYSTEM\user;..\HARDWARE\CODE;..\HARDWARE\ADC;..\HARDWARE\SCREEN;..\SYSTEM\usart;..\HARDWARE\LAN;..\HARDWARE\LOCK;..\HARDWARE\TOOL;..\HARDWARE\AT24C256
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/GPRS/: gprs.c
    ./: slave.c
    ../HARDWARE/CODE/: code.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SCREEN/: cmd_queue.c hmi_driver.c hmi_user_uart.c hw_config.c ulitity.c hmi_handle.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LAN/: lan.c
    ../HARDWARE/LOCK/: lock.c
    ../HARDWARE/AT24C256/: AT24C256.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/user/: user.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
