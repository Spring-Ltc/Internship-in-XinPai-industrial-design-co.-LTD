# Keil uVision project MasterControl.uvproj, settings and files
target MasterControl (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MasterControl +hex
  c flags: Optimize=8 SizeSpeed=1
  group procedure
    ./procedure/: main.c EEPROM.c GPIO.c timer.c USART1.C CupDet.c TimeInterval.c MasterControl.c TaskUart.c ResidueDegree.c
  group txt
    ./: 头文件说明.txt
