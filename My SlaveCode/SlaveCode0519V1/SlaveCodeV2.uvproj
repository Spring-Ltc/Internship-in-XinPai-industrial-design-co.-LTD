# Keil uVision project SlaveCodeV2.uvproj, settings and files
target SlaveCodeV2 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SlaveCodeV2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\FWLIB
  group LIB
    ./FWLIB/: delay.c EEPROM.c GPIO.c timer.c USART.C
  group USER
    ./USER/: main.c TaskUart.c TimeProcess.c TaskState.c TaskEEPROM.c TaskControl.c
